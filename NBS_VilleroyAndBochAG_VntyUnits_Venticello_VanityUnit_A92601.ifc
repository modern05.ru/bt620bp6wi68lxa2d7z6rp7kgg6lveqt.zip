Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-04-22T14:56:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220111_1110(x64) - Exporter 19.2.50.16 - Alternate UI 19.2.50.16
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Fri Apr 22 14:56:35 2022* Host: NCL-ManOps17* Database: C:\Users\bateyjo\AppData\Local\Temp\{27D0E6F9-44A1-4C4D-BE31-253C86D85A26}\ifc* Database version: 5507* Database creation date: Fri Apr 22 14:56:25 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Fri Apr 22 14:56:35 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Fri Apr 22 14:56:35 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: A92601VH, NBS_VilleroyAndBochAG_VanityUnits_VenticelloVanityUnitA92601:A92601VH:392371
In: Level 0
Type - ElementType: A92601VH; Classification: Pr_40_20_76_94 (Uniclass2015); Material: NBS_VilleroyAndBoch_GlossyWhite, NBS_VilleroyAndBoch_Chrome
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_VanityUnits_Venticello_VanityUnit_A92601VH; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/u1orsh5d; ProductInformation: https://pro.villeroy-boch.com/en/euo/bw/m/A92601; Uniclass2015Title: Vanity units; Uniclass2015Code: Pr_40_20_76_94; Uniclass2015Version: Products v1.22; Version: 3
Type - NBS_Data - ColourFinish: Chrome, glossy; ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; EmbodiedCarbon: n/a; Form: Wall-mounted; IntegralAccessories: Vanity washbasin; Material: n/a; MaterialsCarcassFinishAndColour: Arizona oak; MaterialsCarcassFrameAndPanels: Chipboard; Recyclability: n/a; RecycledContent: n/a; SizeNominal: 953 x 590 x 477 mm; WorktopFinishAndColour: n/a; WorktopMaterials: n/a
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_76_94:Vanity units; CodePerformance: n/a; Color: Beige, Brown, Black, Grey, White; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: marketing@villeroy-boch.co.uk; Material: n/a; ModelNumber: A92601VH; ModelReference: Venticello_VanityUnit_A92601VH; Name: VanityUnits_Venticello_VanityUnit_A92601VH_VilleroyAndBochAG; NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
